options:
  parameters:
    author: main
    generate_options: qt_gui
    id: correlator_test
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: channel
  id: variable_qtgui_chooser
  parameters:
    label: Drone ID Channel
    label0: Ch 1
    label1: Ch 2
    label2: Ch 3
    label3: Ch 4
    label4: Ch  5
    num_opts: '5'
    option0: '0'
    option1: 2.4145e9
    option2: 2.4295e9
    option3: 2.4445e9
    option4: 2.4595e9
    type: real
    value: 2.3995e9
  states: {state: disabled}
- name: correlation_mag_scaler
  id: variable_qtgui_range
  parameters:
    label: Correlation Scaler
    outputmsgname: value
    showports: 'False'
    start: '0'
    step: '0.01'
    stop: '10'
    value: '1'
  states: {}
- name: decimation
  id: variable
  parameters:
    value: '2'
  states: {}
- name: delay
  id: variable_qtgui_range
  parameters:
    label: Delay
    outputmsgname: value
    rangeType: int
    showports: 'False'
    start: '0'
    step: '1'
    stop: '100000'
    value: int(fft_size * 4) + long_cp_len + (short_cp_len * 3)
  states: {}
- name: fft_size
  id: variable
  parameters:
    value: samp_rate / decimation / 15e3
  states: {}
- name: filter_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: 5e6
    gain: '1.0'
    samp_rate: samp_rate
    width: 750e3
    win: window.WIN_HAMMING
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    label: Freq
    outputmsgname: value
    showports: 'False'
    start: 60e6
    step: .5e6
    stop: 6e9
    value: '2429500000'
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    label: Gain
    outputmsgname: value
    showports: 'False'
    start: '0'
    step: '0.05'
    stop: '1'
    value: '.35'
  states: {}
- name: long_cp_len
  id: variable
  parameters:
    value: round(0.0000052 * samp_rate / decimation)
  states: {}
- name: offset
  id: variable_qtgui_range
  parameters:
    label: Offset
    outputmsgname: value
    showports: 'False'
    start: '-samp_rate/2'
    step: .5e6
    stop: samp_rate/2
    value: 7.5e6
  states: {}
- name: samp_rate
  id: variable_qtgui_range
  parameters:
    label: Sample Rate
    outputmsgname: value
    showports: 'False'
    start: 10e6
    step: 1e6
    stop: 56e6
    value: 15.36e6*2
  states: {}
- name: short_cp_len
  id: variable
  parameters:
    value: round(0.00000469 * samp_rate / decimation)
  states: {}
- name: time_domain_mag_offset
  id: variable_qtgui_range
  parameters:
    label: Time Domain Mag^2 Offset
    outputmsgname: value
    showports: 'False'
    start: '-100'
    step: '0.1'
    stop: '100'
    value: '1'
  states: {}
- name: time_domain_mag_scaler
  id: variable_qtgui_range
  parameters:
    label: Time Domain Mag^2 Scaler
    outputmsgname: value
    showports: 'False'
    start: '0'
    step: '0.01'
    stop: '100'
    value: '1'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: offset
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: time_domain_mag_offset
    type: float
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_1
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: delay
    type: complex
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /opt/dji/collects/2437MHz_30.72MSPS.fc32
    repeat: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: correlation_mag_scaler
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: time_domain_mag_scaler
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: fft_filter_xxx_0
  id: fft_filter_xxx
  parameters:
    decim: decimation
    taps: filter_taps
    type: ccc
  states: {}
- name: fft_filter_xxx_1
  id: fft_filter_xxx
  parameters:
    alias: corr_filt
    decim: '1'
    taps: '[(0.01763858+-0.01759975j),(-0.00388397+0.00275807j),(-0.01390060+0.01484881j),(0.01325312+-0.01048136j),(0.00881741+-0.01230320j),(-0.01657599+0.01394610j),(0.00161920+0.00512291j),(0.01819849+-0.01780315j),(-0.00950583+0.00041899j),(-0.01221672+0.01630932j),(0.01823595+-0.00857353j),(0.00533939+-0.01474219j),(-0.02011417+0.01306319j),(0.00639906+0.00831797j),(0.02000275+-0.01817355j),(-0.01474438+-0.00291138j),(-0.01210344+0.01823531j),(0.02334750+-0.00556697j),(0.00363457+-0.01806044j),(-0.02446152+0.01110847j),(0.00940491+0.01289557j),(0.02340473+-0.01767729j),(-0.01850256+-0.00814895j),(-0.01440082+0.01972270j),(0.02760724+-0.00017418j),(0.00503745+-0.02159205j),(-0.02893355+0.00642888j),(0.00885422+0.01855276j),(0.02818713+-0.01433409j),(-0.01864631+-0.01548892j),(-0.01951055+0.01854131j),(0.02866813+0.00843348j),(0.01069245+-0.02297966j),(-0.03114444+-0.00256164j),(0.00276783+0.02297415j),(0.03212885+-0.00570236j),(-0.01230563+-0.02287292j),(-0.02560602+0.01133507j),(0.02275246+0.01870841j),(0.01942053+-0.01794711j),(-0.02643795+-0.01511006j),(-0.00859650+0.02102139j),(0.02977802+0.00855868j),(0.00147073+-0.02443041j),(-0.02658694+-0.00363057j),(0.00740788+0.02425279j),(0.02469227+-0.00308371j),(-0.01058027+-0.02457072j),(-0.01857745+0.00735873j),(0.01486942+0.02190278j),(0.01626261+-0.01270162j),(-0.01395859+-0.02031444j),(-0.01162699+0.01534499j),(0.01565579+0.01652380j),(0.01186154+-0.01889297j),(-0.01392288+-0.01435918j),(-0.00971853+0.01995592j),(0.01646395+0.01057821j),(0.01160634+-0.02209695j),(-0.01652383+-0.00867963j),(-0.00971391+0.02215184j),(0.02103875+0.00544428j),(0.01053460+-0.02349902j),(-0.02236658+-0.00407928j),(-0.00661891+0.02309553j),(0.02698776+0.00146709j),(0.00525385+-0.02407342j),(-0.02705686+-0.00060978j),(0.00032044+0.02349869j),(0.02941959+-0.00142764j),(-0.00215588+-0.02427621j),(-0.02676047+0.00179504j),(0.00683333+0.02362328j),(0.02671798+-0.00321841j),(-0.00648172+-0.02425929j),(-0.02253918+0.00300450j),(0.00823215+0.02358706j),(0.02228678+-0.00369147j),(-0.00482181+-0.02415246j),(-0.01913822+0.00277589j),(0.00410942+0.02353859j),(0.02085658+-0.00263555j),(0.00075302+-0.02409316j),(-0.01995562+0.00097740j),(-0.00168818+0.02354974j),(0.02357755+-0.00002383j),(0.00578003+-0.02402643j),(-0.02361741+-0.00231087j),(-0.00535112+0.02338798j),(0.02696291+0.00397094j),(0.00811686+-0.02351577j),(-0.02547945+-0.00684159j),(-0.00688369+0.02241780j),(0.02642383+0.00903485j),(0.00973954+-0.02176375j),(-0.02213446+-0.01222224j),(-0.00947159+0.01974421j),(0.02047262+0.01466057j),(0.01392311+-0.01786227j),(-0.01418783+-0.01777473j),(-0.01532227+0.01454308j),(0.01140998+0.01993551j),(0.02093667+-0.01117578j),(-0.00482455+-0.02229874j),(-0.02241830+0.00647639j),(0.00235197+0.02334998j),(0.02674007+-0.00177560j),(0.00370173+-0.02400651j),(-0.02549785+-0.00386427j),(-0.00570067+0.02293933j),(0.02597781+0.00912466j),(0.01151729+-0.02093759j),(-0.02028489+-0.01456751j),(-0.01340883+0.01700720j),(0.01639734+0.01889219j),(0.01895844+-0.01198404j),(-0.00706996+-0.02234203j),(-0.01995268+0.00539147j),(0.00085395+0.02376333j),(0.02355149+0.00172946j),(0.00915068+-0.02329168j),(-0.02127081+-0.00923974j),(-0.01423996+0.02021346j),(0.02036066+0.01590018j),(0.02139663+-0.01490856j),(-0.01281531+-0.02110870j),(-0.02215768+0.00746762j),(0.00676604+0.02375680j),(0.02391116+0.00118478j),(0.00467929+-0.02328666j),(-0.01872316+-0.01001141j),(-0.01225830+0.01936907j),(0.01465063+0.01765912j),(0.02201916+-0.01218921j),(-0.00455091+-0.02259578j),(-0.02442482+0.00280149j),(-0.00265858+0.02384916j),(0.02601652+0.00754102j),(0.01330255+-0.02049234j),(-0.01858727+-0.01654419j),(-0.01791104+0.01314484j),(0.01066931+0.02263594j),(0.02274282+-0.00251843j),(0.00362849+-0.02365189j),(-0.01901272+-0.00867479j),(-0.01372881+0.01952101j),(0.01445752+0.01844779j),(0.02432328+-0.01009927j),(-0.00247187+-0.02341052j),(-0.02508303+-0.00177899j),(-0.00684102+0.02267245j),(0.02257626+0.01392442j),(0.01816000+-0.01503782j),(-0.00984830+-0.02183143j),(-0.02076847+0.00327629j),(-0.00250744+0.02381882j),(0.02053474+0.01034473j),(0.01787515+-0.01764356j),(-0.00990281+-0.02027066j),(-0.02400552+0.00603408j),(-0.00092193+0.02408622j),(0.02543539+0.00861474j),(0.01525644+-0.01861755j),(-0.01416012+-0.01968669j),(-0.02063245+0.00674855j),(0.00087798+0.02414493j),(0.02135157+0.00877755j),(0.01633513+-0.01819014j),(-0.00963691+-0.02018542j),(-0.02354786+0.00530972j),(-0.00327377+0.02399031j),(0.02411823+0.01099273j),(0.01857358+-0.01626456j),(-0.01059841+-0.02167872j),(-0.02223257+0.00175569j),(-0.00448061+0.02320601j),(0.01843306+0.01480060j),(0.02059717+-0.01235152j),(-0.00170716+-0.02320245j),(-0.02295945+-0.00399729j),(-0.01333077+0.02065185j),(0.01645931+0.01951942j),(0.02505838+-0.00582326j),(0.00214315+-0.02345175j),(-0.01999106+-0.01141066j),(-0.01612916+0.01515928j),(0.00645063+0.02338843j),(0.02340384+0.00335090j),(0.01455622+-0.02031075j),(-0.01291026+-0.01889784j),(-0.02419076+0.00573076j),(-0.00297354+0.02389695j),(0.02208851+0.01395236j),(0.02000855+-0.01210758j),(-0.00280117+-0.02338124j),(-0.02024105+-0.00674766j),(-0.01533629+0.01816326j),(0.00866513+0.02241716j),(0.02585863+0.00127843j),(0.01291895+-0.02084043j),(-0.01513621+-0.01869518j),(-0.02274968+0.00513630j),(-0.00348731+0.02360889j),(0.01829592+0.01603804j),(0.02167107+-0.00890890j),(0.00376932+-0.02344191j),(-0.01929970+-0.01165016j),(-0.02093116+0.01336495j),(0.00355852+0.02429016j),(0.02449575+0.00939079j),(0.01789285+-0.01510384j),(-0.00521708+-0.02288262j),(-0.02067840+-0.00580343j),(-0.01567718+0.01786577j),(0.00678157+0.02322719j),(0.02526638+0.00484779j),(0.01703504+-0.01802432j),(-0.00944185+-0.02175193j),(-0.02315968+-0.00263679j),(-0.01201339+0.01964799j),(0.00974227+0.02249249j),(0.02337539+0.00322025j),(0.01631611+-0.01869630j),(-0.00804951+-0.02146841j),(-0.02446534+-0.00250510j),(-0.01364863+0.01942189j),(0.01082476+0.02288534j),(0.02338089+0.00467850j),(0.01575323+-0.01745047j),(-0.00486588+-0.02228901j),(-0.02234394+-0.00540305j),(-0.01799248+0.01708638j),(0.00630297+0.02404197j),(0.02421169+0.00909650j),(0.01869056+-0.01371096j),(-0.00120294+-0.02329403j),(-0.01868606+-0.01101386j),(-0.02085532+0.01176855j),(-0.00277376+0.02442844j),(0.02043702+0.01572335j),(0.02426044+-0.00642247j),(0.00627326+-0.02229726j),(-0.01414759+-0.01799391j),(-0.02178119+0.00253727j),(-0.01211465+0.02135323j),(0.01004899+0.02230633j),(0.02564758+0.00475285j),(0.01782657+-0.01625512j),(-0.00461814+-0.02296748j),(-0.02016322+-0.00988523j),(-0.01935510+0.01191721j),(-0.00379767+0.02436674j),(0.01743215+0.01737833j),(0.02572626+-0.00317823j),(0.01138314+-0.02058087j),(-0.01091075+-0.02088622j),(-0.02180484+-0.00400836j),(-0.01659586+0.01652604j),(0.00098250+0.02457448j),(0.02062412+0.01401417j),(0.02470496+-0.00681130j),(0.00803330+-0.02182141j),(-0.01287401+-0.01961780j),(-0.02189717+-0.00203868j),(-0.01614244+0.01754722j),(0.00170233+0.02453998j),(0.02112234+0.01391701j),(0.02457703+-0.00635587j),(0.00866988+-0.02141619j),(-0.01106682+-0.02041379j),(-0.02146480+-0.00424042j),(-0.01851272+0.01541975j),(-0.00164649+0.02466325j),(0.01894224+0.01713733j),(0.02514208+-0.00175954j),(0.01307692+-0.01886615j),(-0.00517634+-0.02247708j),(-0.01936213+-0.01029778j),(-0.02241350+0.00928574j),(-0.00890280+0.02312654j),(0.01256998+0.02212150j),(0.02398657+0.00708364j),(0.01952637+-0.01201364j),(0.00524744+-0.02275797j),(-0.01271070+-0.01836548j),(-0.02419436+-0.00180839j),(-0.01820126+0.01634620j),(0.00055342+0.02472033j),(0.01685399+0.01822036j),(0.02330613+0.00103395j),(0.01810987+-0.01621768j),(0.00084468+-0.02311348j),(-0.01802187+-0.01564036j),(-0.02354118+0.00160323j),(-0.01460085+0.01832832j),(0.00074512+0.02475890j),(0.01693226+0.01731257j),(0.02546714+0.00044119j),(0.01773777+-0.01615047j),(-0.00043574+-0.02309909j),(-0.01559617+-0.01662575j),(-0.02235234+-0.00049757j),(-0.01867132+0.01630125j),(-0.00287727+0.02463726j),(0.01586464+0.02012312j),(0.02394619+0.00532412j),(0.01962936+-0.01177913j),(0.00759392+-0.02217363j),(-0.00942869+-0.02055810j),(-0.02291287+-0.00792285j),(-0.02224326+0.00915674j),(-0.00968967+0.02198525j),(0.00545216+0.02418903j),(0.01891447+0.01483349j),(0.02519027+-0.00132473j),(0.01746154+-0.01634824j),(0.00064014+-0.02301200j),(-0.01380391+-0.01823975j),(-0.02187679+-0.00445444j),(-0.02171414+0.01176517j),(-0.00973646+0.02289019j),(0.00817926+0.02389323j),(0.02015668+0.01445096j),(0.02308617+-0.00103487j),(0.01827180+-0.01557942j),(0.00441737+-0.02280573j),(-0.01288797+-0.01967344j),(-0.02229476+-0.00767090j),(-0.02140005+0.00794310j),(-0.01377200+0.02050982j),(0.00042672+0.02483528j),(0.01657016+0.01926092j),(0.02416496+0.00620496j),(0.02099713+-0.00892942j),(0.01196101+-0.02003610j),(-0.00187408+-0.02278609j),(-0.01707514+-0.01623877j),(-0.02401979+-0.00306393j),(-0.02011840+0.01158394j),(-0.01076914+0.02211560j),(0.00239261+0.02465612j),(0.01711242+0.01840249j),(0.02455795+0.00577834j),(0.02129721+-0.00853951j),(0.01254094+-0.01937935j),(0.00024369+-0.02296327j),(-0.01443504+-0.01816794j),(-0.02341480+-0.00678260j),(-0.02211734+0.00719352j),(-0.01498718+0.01897999j),(-0.00404817+0.02467978j),(0.01060410+0.02252930j),(0.02173449+0.01335831j),(0.02352400+0.00023656j),(0.01919379+-0.01257813j),(0.01054860+-0.02106155j),(-0.00346251+-0.02266944j),(-0.01673086+-0.01702626j),(-0.02236934+-0.00596229j),(-0.02210619+0.00710477j),(-0.01724887+0.01827684j),(-0.00542239+0.02434544j),(0.00886740+0.02365639j),(0.01815935+0.01652154j),(0.02272124+0.00507236j),(0.02323474+-0.00743489j),(0.01585477+-0.01757680j),(0.00290380+-0.02266571j),(-0.00838596+-0.02143520j),(-0.01725668+-0.01433876j),(-0.02397609+-0.00333608j),(-0.02334963+0.00869879j),(-0.01507077+0.01871835j),(-0.00520559+0.02426454j),(0.00526349+0.02407601j),(0.01686169+0.01832575j),(0.02368686+0.00848698j),(0.02285306+-0.00305227j),(0.01857744+-0.01357728j),(0.01120531+-0.02071451j),(-0.00103141+-0.02294526j),(-0.01274272+-0.01987383j),(-0.01929372+-0.01227800j),(-0.02310373+-0.00189834j),(-0.02352449+0.00900949j),(-0.01678265+0.01817462j),(-0.00635545+0.02375155j),(0.00284804+0.02468764j),(0.01242594+0.02091316j),(0.02138224+0.01327730j),(0.02412815+0.00332766j),(0.02149192+-0.00699342j),(0.01731976+-0.01574398j),(0.00946710+-0.02136599j),(-0.00220353+-0.02292562j),(-0.01170079+-0.02023332j),(-0.01784611+-0.01386406j),(-0.02327040+-0.00501172j),(-0.02471278+0.00477633j),(-0.01970955+0.01386125j),(-0.01285911+0.02077040j),(-0.00568049+0.02445257j),(0.00450889+0.02442333j),(0.01437037+0.02077892j),(0.01950391+0.01415874j),(0.02252471+0.00563749j),(0.02420351+-0.00348431j),(0.02045640+-0.01189218j),(0.01289326+-0.01841831j),(0.00603886+-0.02220266j),(-0.00195073+-0.02281651j),(-0.01187089+-0.02027311j),(-0.01860115+-0.01498356j),(-0.02151643+-0.00770434j),(-0.02405629+0.00058277j),(-0.02378548+0.00883518j),(-0.01827840+0.01606664j),(-0.01184778+0.02144390j),(-0.00591867+0.02439938j),(0.00270819+0.02468346j),(0.01156613+0.02234318j),(0.01659914+0.01770591j),(0.02048249+0.01134561j),(0.02426971+0.00398235j),(0.02372380+-0.00361383j),(0.01969741+-0.01067837j),(0.01619623+-0.01653253j),(0.01099186+-0.02066803j),(0.00249666+-0.02276534j),(-0.00471727+-0.02269407j),(-0.00991670+-0.02053572j),(-0.01648641+-0.01656101j),(-0.02193473+-0.01116509j),(-0.02310976+-0.00483625j),(-0.02344047+0.00187335j),(-0.02386140+0.00842109j),(-0.02047137+0.01432334j),(-0.01482280+0.01916178j),(-0.01065511+0.02261725j),(-0.00530402+0.02450742j),(0.00249282+0.02476861j),(0.00831091+0.02343803j),(0.01222397+0.02066798j),(0.01766374+0.01670301j),(0.02191821+0.01183085j),(0.02242897+0.00637507j),(0.02290666+0.00068771j),(0.02374963+-0.00489894j),(0.02108920+-0.01009364j),(0.01685052+-0.01463347j),(0.01425188+-0.01830644j),(0.01014470+-0.02097801j),(0.00359763+-0.02256942j),(-0.00111850+-0.02304756j),(-0.00475025+-0.02244752j),(-0.01056683+-0.02085841j),(-0.01552328+-0.01839054j),(-0.01753544+-0.01518538j),(-0.02039941+-0.01141883j),(-0.02387978+-0.00726502j),(-0.02413950+-0.00288884j),(-0.02340602+0.00153564j),(-0.02432402+0.00584651j),(-0.02333232+0.00991650j),(-0.01986311+0.01363157j),(-0.01798616+0.01688845j),(-0.01631785+0.01962228j),(-0.01180451+0.02179605j),(-0.00775218+0.02337789j),(-0.00570679+0.02436075j),(-0.00179884+0.02476964j),(0.00318093+0.02463208j),(0.00556684+0.02397991j),(0.00792766+0.02287066j),(0.01237445+0.02136691j),(0.01506705+0.01951924j),(0.01586260+0.01738945j),(0.01860229+0.01504935j),(0.02131307+0.01255311j),(0.02120088+0.00994925j),(0.02174744+0.00729828j),(0.02389086+0.00464873j),(0.02368491+0.00203057j),(0.02237166+-0.00051844j),(0.02328711+-0.00296093j),(0.02345981+-0.00528187j),(0.02123050+-0.00746818j),(0.02053854+-0.00949707j),(0.02099309+-0.01136173j),(0.01894061+-0.01306795j),(0.01681194+-0.01460908j),(0.01701462+-0.01598154j),(0.01588229+-0.01720018j),(0.01304182+-0.01827322j),(0.01241037+-0.01919918j),(0.01229429+-0.01999246j),(0.00973112+-0.02067153j),(0.00804623+-0.02123886j),(0.00843785+-0.02170265j),(0.00696066+-0.02208452j),(0.00456523+-0.02239297j),(0.00470046+-0.02262955j),(0.00456995+-0.02281159j),(0.00224442+-0.02295344j),(0.00156845+-0.02305363j),(0.00240400+-0.02312028j),(0.00098607+-0.02317014j),(-0.00051374+-0.02320353j),(0.00050009+-0.02321878j),(0.00045776+-0.02322941j),(-0.00131008+-0.02324041j),(-0.00087251+-0.02324385j),(0.00032002+-0.02324492j),(-0.00088102+-0.02325229j),(-0.00132710+-0.02325730j),(0.00043224+-0.02325473j),(0.00046606+-0.02325254j),(-0.00055627+-0.02324573j),(0.00093504+-0.02322077j),(0.00234447+-0.02317935j),(0.00150042+-0.02312113j),(0.00216789+-0.02302937j),(0.00448493+-0.02289594j),(0.00460695+-0.02272233j),(0.00446323+-0.02249417j),(0.00685018+-0.02219413j),(0.00831890+-0.02182068j),(0.00791880+-0.02136529j),(0.00959522+-0.02080637j),(0.01214993+-0.02013569j),(0.01225755+-0.01935081j),(0.01288054+-0.01843323j),(0.01571257+-0.01736857j),(0.01683646+-0.01615831j),(0.01662535+-0.01479422j),(0.01874559+-0.01326144j),(0.02078965+-0.01156357j),(0.02032669+-0.00970726j),(0.02101025+-0.00768671j),(0.02323116+-0.00550873j),(0.02305008+-0.00319611j),(0.02212625+-0.00076193j),(0.02343113+0.00177878j),(0.02362872+0.00438864j),(0.02147695+0.00702990j),(0.02092206+0.00967260j),(0.02102591+0.01226820j),(0.01830682+0.01475618j),(0.01555882+0.01708805j),(0.01475498+0.01920960j),(0.01205410+0.02104906j),(0.00759903+0.02254460j),(0.00522996+0.02364565j),(0.00283580+0.02428964j),(-0.00215220+0.02441904j),(-0.00606837+0.02400199j),(-0.00812197+0.02301099j),(-0.01218249+0.02142103j),(-0.01670401+0.01923914j),(-0.01838048+0.01649720j),(-0.02026558+0.01323224j),(-0.02374292+0.00950911j),(-0.02474275+0.00543106j),(-0.02383284+0.00111215j),(-0.02457441+-0.00332035j),(-0.02432276+-0.00770454j),(-0.02085044+-0.01186634j),(-0.01799451+-0.01564086j),(-0.01599037+-0.01885398j),(-0.01104192+-0.02132979j),(-0.00523332+-0.02292682j),(-0.00160954+-0.02353476j),(0.00309865+-0.02306451j),(0.00963778+-0.02148096j),(0.01373706+-0.01881724j),(0.01632781+-0.01515210j),(0.02055862+-0.01062007j),(0.02321120+-0.00543317j),(0.02236040+0.00014572j),(0.02187490+0.00582533j),(0.02135635+0.01127338j),(0.01709411+0.01613784j),(0.01164660+0.02009512j),(0.00772582+0.02285751j),(0.00190003+0.02418045j),(-0.00590449+0.02391164j),(-0.01126323+0.02201387j),(-0.01543856+0.01855082j),(-0.02109475+0.01370484j),(-0.02449236+0.00779506j),(-0.02407900+0.00123981j),(-0.02375583+-0.00547727j),(-0.02258831+-0.01181357j),(-0.01714748+-0.01721692j),(-0.01058524+-0.02119903j),(-0.00539325+-0.02336477j),(0.00181327+-0.02344339j),(0.01030108+-0.02135341j),(0.01549809+-0.01722522j),(0.01899193+-0.01137834j),(0.02301101+-0.00432105j),(0.02354963+0.00326790j),(0.01975516+0.01062396j),(0.01586459+0.01697709j),(0.01082437+0.02160722j),(0.00195926+0.02394037j),(-0.00667475+0.02364921j),(-0.01261097+0.02068667j),(-0.01904868+0.01530237j),(-0.02456282+0.00806391j),(-0.02484066+-0.00019547j),(-0.02230780+-0.00848953j),(-0.01939949+-0.01577567j),(-0.01267617+-0.02107210j),(-0.00276292+-0.02362235j),(0.00521979+-0.02301533j),(0.01206734+-0.01923778j),(0.01962366+-0.01271841j),(0.02336398+-0.00431727j),(0.02167843+0.00479782j),(0.01865091+0.01331240j),(0.01351068+0.01992594j),(0.00364254+0.02356375j),(-0.00655347+0.02358642j),(-0.01373868+0.01989770j),(-0.02059567+0.01298204j),(-0.02560544+0.00389065j),(-0.02416955+-0.00590384j),(-0.01875171+-0.01476260j),(-0.01261282+-0.02113823j),(-0.00312195+-0.02383687j),(0.00854232+-0.02228354j),(0.01638866+-0.01666781j),(0.02055453+-0.00792348j),(0.02318451+0.00239139j),(0.02043239+0.01233487j),(0.01146992+0.01996460j),(0.00188587+0.02373299j),(-0.00732373+0.02279084j),(-0.01775700+0.01720788j),(-0.02450487+0.00803676j),(-0.02409011+-0.00287702j),(-0.02028606+-0.01326259j),(-0.01374098+-0.02086429j),(-0.00203556+-0.02394156j),(0.01019532+-0.02171662j),(0.01756163+-0.01458515j),(0.02183148+-0.00406587j),(0.02265956+0.00746769j),(0.01582869+0.01730082j),(0.00422483+0.02304547j),(-0.00624986+0.02322842j),(-0.01612061+0.01767670j),(-0.02440502+0.00765165j),(-0.02503698+-0.00438867j),(-0.01832302+-0.01539677j),(-0.00945772+-0.02249858j),(0.00182667+-0.02373443j),(0.01477230+-0.01865082j),(0.02214697+-0.00851416j),(0.02162822+0.00398788j),(0.01706112+0.01543188j),(0.00776400+0.02256160j),(-0.00653093+0.02324556j),(-0.01836250+0.01717191j),(-0.02322486+0.00599483j),(-0.02349301+-0.00707719j),(-0.01785950+-0.01814609j),(-0.00459606+-0.02379415j),(0.00941016+-0.02219110j),(0.01805052+-0.01371247j),(0.02237594+-0.00090253j),(0.02058168+0.01221451j),(0.00944658+0.02138083j),(-0.00521035+0.02352668j),(-0.01615397+0.01782232j),(-0.02328871+0.00603130j),(-0.02459070+-0.00794931j),(-0.01561542+-0.01933910j),(-0.00094113+-0.02413884j),(0.01135172+-0.02055928j),(0.02010364+-0.00972375j),(0.02336008+0.00458982j),(0.01591029+0.01720974j),(0.00118626+0.02345919j),(-0.01197966+0.02091453j),(-0.02133304+0.01037878j),(-0.02523851+-0.00427314j),(-0.01829790+-0.01745198j),(-0.00310083+-0.02400326j),(0.01073033+-0.02125717j),(0.01976254+-0.01015436j),(0.02292653+0.00497621j),(0.01532793+0.01802839j),(-0.00081927+0.02359902j),(-0.01502170+0.01926989j),(-0.02265340+0.00669953j),(-0.02355173+-0.00891805j),(-0.01414851+-0.02092413j),(0.00315332+-0.02405991j),(0.01700428+-0.01683705j),(0.02181522+-0.00229589j),(0.01888235+0.01318659j),(0.00690161+0.02262555j),(-0.01101739+0.02161926j),(-0.02299831+0.01049104j),(-0.02316414+-0.00573173j),(-0.01509439+-0.01952015j),(-0.00065343+-0.02429546j),(0.01616494+-0.01763472j),(0.02389068+-0.00261417j),(0.01761194+0.01354112j),(0.00414674+0.02289380j),(-0.01099794+0.02068721j),(-0.02355431+0.00785592j),(-0.02422667+-0.00922639j),(-0.01074518+-0.02186431j),(0.00627478+-0.02348246j),(0.01830763+-0.01309054j),(0.02262192+0.00401019j),(0.01453787+0.01880671j),(-0.00420648+0.02331843j),(-0.02000293+0.01498004j),(-0.02368630+-0.00182110j),(-0.01693241+-0.01795157j),(-0.00177424+-0.02442712j),(0.01639709+-0.01748068j),(0.02412431+-0.00089115j),(0.01558734+0.01597816j),(-0.00060185+0.02342245j),(-0.01594981+0.01698990j),(-0.02489208+0.00026289j),(-0.01937465+-0.01698258j),(-0.00050994+-0.02445753j),(0.01675346+-0.01756350j),(0.02194798+-0.00031359j),(0.01549416+0.01687115j),(-0.00080805+0.02336950j),(-0.01956431+0.01499380j),(-0.02555894+-0.00316231j),(-0.01407676+-0.01972087j),(0.00387995+-0.02411477j),(0.01815750+-0.01337181j),(0.02261638+0.00572415j),(0.01119851+0.02076075j),(-0.01027548+0.02176458j),(-0.02378735+0.00792261j),(-0.02073710+-0.01166201j),(-0.00655238+-0.02384237j),(0.01169986+-0.02023245j),(0.02376405+-0.00312680j),(0.01756330+0.01576917j),(-0.00302628+0.02329423j),(-0.01989332+0.01404993j),(-0.02284616+-0.00561099j),(-0.01244888+-0.02178506j),(0.00728716+-0.02278810j),(0.02319372+-0.00772838j),(0.01973848+0.01254395j),(0.00031797+0.02316643j),(-0.01752725+0.01617323j),(-0.02328236+-0.00341306j),(-0.01425954+-0.02099251j),(0.00664748+-0.02319640j),(0.02331891+-0.00818653j),(0.01923788+0.01263876j),(-0.00040386+0.02319894j),(-0.01798231+0.01515042j),(-0.02319131+-0.00538400j),(-0.01229720+-0.02226184j),(0.00999677+-0.02195641j),(0.02434003+-0.00455364j),(0.01604609+0.01600310j),(-0.00518349+0.02299175j),(-0.02074064+0.01054250j),(-0.02154841+-0.01125960j),(-0.00600294+-0.02434147j),(0.01644221+-0.01762867j),(0.02426372+0.00337979j),(0.00866567+0.02093382j),(-0.01349737+0.01998132j),(-0.02316326+0.00116600j),(-0.01552895+-0.01936448j),(0.00489266+-0.02366708j),(0.02288064+-0.00779149j),(0.01905808+0.01435519j),(-0.00415179+0.02306118j),(-0.02223238+0.01040225j),(-0.02006210+-0.01237916j),(-0.00257792+-0.02465827j),(0.01731670+-0.01507409j),(0.02283900+0.00773453j),(0.00493151+0.02268122j),(-0.01936267+0.01572689j),(-0.02371281+-0.00676123j),(-0.00623337+-0.02364582j),(0.01438717+-0.01880586j),(0.02201631+0.00332458j),(0.00946171+0.02153294j),(-0.01501010+0.01807106j),(-0.02582517+-0.00385431j),(-0.00940766+-0.02281595j),(0.01495970+-0.02004212j),(0.02202077+0.00187621j),(0.00838948+0.02115027j),(-0.01336429+0.01830765j),(-0.02450863+-0.00397521j),(-0.01078882+-0.02308837j),(0.01569011+-0.01935874j),(0.02392356+0.00351545j),(0.00544088+0.02189697j),(-0.01701567+0.01653773j),(-0.02201465+-0.00712924j),(-0.00655104+-0.02420616j),(0.01656124+-0.01642505j),(0.02316654+0.00807195j),(0.00223175+0.02297375j),(-0.02225544+0.01205102j),(-0.02062143+-0.01296157j),(0.00245018+-0.02475074j),(0.02035457+-0.01021511j),(0.01698212+0.01473450j),(-0.00479837+0.02230807j),(-0.02405795+0.00383826j),(-0.01644163+-0.01999041j),(0.01161641+-0.02213279j),(0.02455904+-0.00001102j),(0.00736853+0.02113068j),(-0.01662985+0.01687980j),(-0.02153153+-0.00802806j),(-0.00408852+-0.02465853j),(0.01872438+-0.01338172j),(0.02080758+0.01268143j),(-0.00425119+0.02262927j),(-0.02546509+0.00446639j),(-0.01418121+-0.02015886j),(0.01328869+-0.02156838j),(0.02213978+0.00209671j),(0.00519009+0.02213774j),(-0.01738613+0.01391213j),(-0.02124442+-0.01265423j),(0.00089345+-0.02469168j),(0.02381239+-0.00705952j),(0.01521708+0.01828689j),(-0.01456920+0.01942309j),(-0.02419403+-0.00522223j),(-0.00293785+-0.02442353j),(0.01937043+-0.01356869j),(0.01721030+0.01358739j),(-0.00569934+0.02199681j),(-0.02344721+0.00055053j),(-0.01180893+-0.02287978j),(0.01736723+-0.01746149j),(0.02291610+0.00979998j),(-0.00447164+0.02280180j),(-0.02474143+0.00412548j),(-0.01082613+-0.02136534j),(0.01515031+-0.01936571j),(0.02017119+0.00760639j),(-0.00029791+0.02297822j),(-0.02180382+0.00558633j),(-0.01532691+-0.02084437j),(0.01409426+-0.01977065j),(0.02427788+0.00746627j),(-0.00207474+0.02294241j),(-0.02515358+0.00489499j),(-0.01104608+-0.02140500j),(0.01673671+-0.01877310j),(0.01940118+0.00922002j),(-0.00363608+0.02269900j),(-0.02189215+0.00216139j),(-0.01096697+-0.02294136j),(0.01704638+-0.01614275j),(0.02146772+0.01282455j),(-0.00794443+0.02157766j),(-0.02618127+-0.00286864j),(-0.00356489+-0.02449500j),(0.02323552+-0.01117854j),(0.01337505+0.01737378j),(-0.01480595+0.01845229j),(-0.02008447+-0.00973817j),(0.00256215+-0.02470990j),(0.02168193+-0.00357103j),(0.00961393+0.02158880j),(-0.01896089+0.01210319j),(-0.01963154+-0.01758030j),(0.01226390+-0.02152289j),(0.02498351+0.00651609j),(-0.00368589+0.02282988j),(-0.02544639+0.00178790j),(-0.00556671+-0.02360365j),(0.02100917+-0.01319132j),(0.01364648+0.01666282j),(-0.01325657+0.01837860j),(-0.01971550+-0.01099600j),(0.00369291+-0.02426533j),(0.02293077+0.00021205j),(0.00579169+0.02279006j),(-0.02312596+0.00650691j),(-0.01377748+-0.02206335j),(0.02044061+-0.01585712j),(0.01941082+0.01495775j),(-0.01518360+0.01927720j),(-0.02220819+-0.01016980j),(0.00821958+-0.02421550j),(0.02262671+0.00081191j),(-0.00006447+0.02285208j),(-0.02086471+0.00448657j),(-0.00797556+-0.02324057j),(0.01805930+-0.01287617j),(0.01550469+0.01800651j),(-0.01429496+0.01612799j),(-0.02116446+-0.01544021j),(0.01064431+-0.02180374j),(0.02511146+0.00826508j),(-0.00656036+0.02208635j),(-0.02635085+-0.00471061j),(0.00285545+-0.02484618j),(0.02590055+-0.00260856j),(0.00151923+0.02252375j),(-0.02324422+0.00565692j),(-0.00564362+-0.02311142j),(0.02012448+-0.01198163j),(0.01060470+0.01913652j),(-0.01612061+0.01375097j),(-0.01497921+-0.01855992j),(0.01313874+-0.01864052j),(0.01969528+0.01388930j),(-0.01024188+0.01897994j),(-0.02289766+-0.01297947j),(0.00898346+-0.02251392j),(0.02567490+0.00829177j),(-0.00762545+0.02168184j),(-0.02621401+-0.00757041j),(0.00738953+-0.02423742j),(0.02624283+0.00325649j),(-0.00606391+0.02268076j),(-0.02432289+-0.00301084j),(0.00508189+-0.02471912j),(0.02288677+-0.00070921j),(-0.00237157+0.02287168j),(-0.02063159+0.00030671j),(0.00008449+-0.02475648j),(0.02019551+-0.00329145j),(0.00345584+0.02289011j),(-0.01978428+0.00213488j),(-0.00546033+-0.02478600j),(0.02165582+-0.00431751j),(0.00760878+0.02296855j),(-0.02315494+0.00239354j),(-0.00708985+-0.02486267j),(0.02611751+-0.00381419j),(0.00624053+0.02303512j),(-0.02734557+0.00121452j),(-0.00273325+-0.02484907j),(0.02884997+-0.00199281j),(-0.00024142+0.02294122j),(-0.02761093+-0.00115952j),(0.00470759+-0.02461541j),(0.02644933+0.00093286j),(-0.00714949+0.02256909j),(-0.02288929+-0.00459791j),(0.01001978+-0.02400982j),(0.02053184+0.00494132j),(-0.01021289+0.02165675j),(-0.01701486+-0.00916683j),(0.01112326+-0.02257625j),(0.01598886+0.01010683j),(-0.01018562+0.01949248j),(-0.01438195+-0.01481467j),(0.01141051+-0.01934048j),(0.01521281+0.01608428j),(-0.01206190+0.01491348j),(-0.01438542+-0.02073793j),(0.01584389+-0.01311707j),(0.01445882+0.02149538j),(-0.01897992+0.00695941j),(-0.01097459+-0.02496196j),(0.02430611+-0.00346686j),(0.00702990+0.02387776j),(-0.02695673+-0.00399747j),(0.00110914+-0.02478917j),(0.02942465+0.00820808j),(-0.00894163+0.02067896j),(-0.02677483+-0.01544431j),(0.01909190+-0.01827317j),(0.02243210+0.01839055j),(-0.02591810+0.01102543j),(-0.01260941+-0.02317432j),(0.03183338+-0.00599552j),(0.00248067+0.02268924j),(-0.03142327+-0.00283829j),(0.01042196+-0.02324803j),(0.02840599+0.00817339j),(-0.01976433+0.01828951j),(-0.01889172+-0.01573242j),(0.02795010+-0.01456927j),(0.00862557+0.01832590j),(-0.02915380+0.00621035j),(0.00482560+-0.02180224j),(0.02740380+-0.00037603j),(-0.01459584+0.01952921j),(-0.01868915+-0.00833408j),(0.02322657+-0.01785406j),(0.00923519+0.01272718j),(-0.02462280+0.01094846j),(0.00348175+-0.01821206j),(0.02320314+-0.00571021j),(-0.01223934+0.01810048j),(-0.01487181+-0.00303782j),(0.01988380+-0.01829157j),(0.00628858+0.00820836j),(-0.02021617+0.01296199j),(0.00524589+-0.01483497j),(0.01815093+-0.00865789j),(-0.01229325+0.01623340j),(-0.00957386+0.00035149j),(0.01813896+-0.01786222j),(0.00156817+0.00507228j),(-0.01661852+0.01390390j),(0.00878338+-0.01233696j),(0.01322760+-0.01050668j),(-0.01391762+0.01483193j),(-0.00389248+0.00274962j)]'
    type: ccc
  states: {}
- name: fosphor_glfw_sink_c_0
  id: fosphor_glfw_sink_c
  parameters:
    freq_center: '0'
    freq_span: samp_rate
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    nconnections: '2'
    size: '10240'
    srate: samp_rate
    tr_level: '.7'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
    ymax: '0.005'
    ymin: '-0.005'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    bw0: 11e6
    center_freq0: uhd.tune_request_t(freq, 6e6)
    dev_args: '""'
    gain0: gain
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [blocks_add_const_vxx_0, '0', qtgui_time_sink_x_1, '1']
- [blocks_complex_to_mag_squared_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_complex_to_mag_squared_0_1, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_delay_0, '0', blocks_complex_to_mag_squared_0_1, '0']
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_multiply_xx_0, '0', fft_filter_xxx_0, '0']
- [blocks_throttle_0, '0', blocks_multiply_xx_0, '0']
- [fft_filter_xxx_0, '0', blocks_delay_0, '0']
- [fft_filter_xxx_0, '0', fft_filter_xxx_1, '0']
- [fft_filter_xxx_0, '0', fosphor_glfw_sink_c_0, '0']
- [fft_filter_xxx_1, '0', blocks_complex_to_mag_squared_0, '0']
- [uhd_usrp_source_0, '0', fft_filter_xxx_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-205-g0427b2a6
