options:
  parameters:
    generate_options: qt_gui
    id: autocorrelator_test
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: bb_gain
  id: variable_qtgui_range
  parameters:
    label: BB Gain
    outputmsgname: value
    rangeType: int
    showports: 'False'
    start: '0'
    step: '2'
    stop: '62'
    value: '0'
  states: {}
- name: burst_threshold
  id: variable_qtgui_range
  parameters:
    label: Burst Detection Threshold
    outputmsgname: value
    showports: 'False'
    start: '0'
    step: '0.05'
    stop: '1'
    value: '.7'
  states: {}
- name: channels_2ghz
  id: variable
  parameters:
    value: '[i - 1 for i in [5, 10, 15, 20, 25, 30, 35, 40, 45, 50, 55, 60, 65, 70]]'
  states: {}
- name: channels_5ghz
  id: variable
  parameters:
    value: '[i - 1 for i in list(range(5, 114, 5))]'
  states: {}
- name: fft_size
  id: variable
  parameters:
    value: int(samp_rate / 15e3)
  states: {}
- name: fosphor_channel
  id: variable_qtgui_chooser
  parameters:
    label: Fosphor Input
    label0: Original Samples
    label1: Low Pass Output
    num_opts: '2'
    option0: '0'
    option1: '1'
    type: int
    value: '0'
  states: {}
- name: freq
  id: variable_qtgui_chooser
  parameters:
    label: Channel
    labels: '[str(i) for i in frequencies]'
    num_opts: '0'
    options: frequencies
    type: real
    value: frequencies[0]
  states: {}
- name: frequencies
  id: variable
  parameters:
    value: frequencies_2ghz + frequencies_5ghz
  states: {}
- name: frequencies_2ghz
  id: variable
  parameters:
    value: '[(i * 1e6) + 2.4055e9 for i in channels_2ghz]'
  states: {}
- name: frequencies_5ghz
  id: variable
  parameters:
    value: '[(i * 1e6) + 5.7325e9 for i in channels_5ghz]'
  states: {}
- name: if_gain
  id: variable_qtgui_range
  parameters:
    label: IF Gain
    outputmsgname: value
    rangeType: int
    showports: 'False'
    start: '0'
    step: '8'
    stop: '40'
    value: '0'
  states: {}
- name: long_cp_len
  id: variable
  parameters:
    value: dji_droneid.utils.get_cyclic_prefix_lengths(samp_rate)[0]
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 15.36e6
  states: {}
- name: short_cp_len
  id: variable
  parameters:
    value: dji_droneid.utils.get_cyclic_prefix_lengths(samp_rate)[1]
  states: {}
- name: zc_seq
  id: variable
  parameters:
    value: dji_droneid.utils.create_zc(fft_size, 4)
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: (fft_size * 4) + (short_cp_len * 3) + long_cp_len + fft_size
    type: complex
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: fosphor_channel
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {state: disabled}
- name: dji_droneid_burst_extractor_0
  id: dji_droneid_burst_extractor
  parameters:
    sample_rate: samp_rate
    threshold: burst_threshold
  states: {}
- name: dji_droneid_detector_0
  id: dji_droneid_detector
  parameters:
    sample_rate: samp_rate
  states: {}
- name: filter_fft_low_pass_filter_0
  id: filter_fft_low_pass_filter
  parameters:
    cutoff_freq: 5e6
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: ccc
    width: 100e3
    win: window.WIN_HAMMING
  states: {}
- name: fosphor_glfw_sink_c_0
  id: fosphor_glfw_sink_c
  parameters:
    freq_center: '0'
    freq_span: samp_rate
  states: {state: disabled}
- name: import_0
  id: import
  parameters:
    imports: from gnuradio import dji_droneid
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    bb_gain0: bb_gain
    bw0: 10e6
    freq0: freq
    gain0: '0'
    gain_mode0: 'False'
    if_gain0: if_gain
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    srate: samp_rate
    type: msg_complex
  states: {}

connections:
- [blocks_delay_0, '0', dji_droneid_burst_extractor_0, '0']
- [blocks_selector_0, '0', fosphor_glfw_sink_c_0, '0']
- [dji_droneid_burst_extractor_0, bursts, qtgui_time_sink_x_1, in]
- [dji_droneid_detector_0, '0', dji_droneid_burst_extractor_0, '1']
- [filter_fft_low_pass_filter_0, '0', blocks_delay_0, '0']
- [filter_fft_low_pass_filter_0, '0', blocks_selector_0, '1']
- [filter_fft_low_pass_filter_0, '0', dji_droneid_detector_0, '0']
- [osmosdr_source_0, '0', blocks_selector_0, '0']
- [osmosdr_source_0, '0', filter_fft_low_pass_filter_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.3.0
