options:
  parameters:
    generate_options: qt_gui
    id: autocorrelator_test
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: bb_gain
  id: variable_qtgui_range
  parameters:
    label: BB Gain
    outputmsgname: value
    rangeType: int
    showports: 'False'
    start: '0'
    step: '2'
    stop: '62'
    value: '0'
  states: {}
- name: channels_2ghz
  id: variable
  parameters:
    value: '[i - 1 for i in [5, 10, 15, 20, 25, 30, 35, 40, 45, 50, 55, 60, 65, 70]]'
  states: {}
- name: channels_5ghz
  id: variable
  parameters:
    value: '[i - 1 for i in list(range(5, 114, 5))]'
  states: {}
- name: fft_size
  id: variable
  parameters:
    value: int(samp_rate / 15e3)
  states: {}
- name: fosphor_channel
  id: variable_qtgui_chooser
  parameters:
    label: Fosphor Input
    label0: Original Samples
    label1: Low Pass Output
    num_opts: '2'
    option0: '0'
    option1: '1'
    type: int
    value: '0'
  states: {}
- name: freq
  id: variable_qtgui_chooser
  parameters:
    label: Channel
    labels: '[str(i) for i in frequencies]'
    num_opts: '0'
    options: frequencies
    type: real
    value: frequencies[0]
  states: {}
- name: frequencies
  id: variable
  parameters:
    value: frequencies_2ghz + frequencies_5ghz
  states: {}
- name: frequencies_2ghz
  id: variable
  parameters:
    value: '[(i * 1e6) + 2.4055e9 for i in channels_2ghz]'
  states: {}
- name: frequencies_5ghz
  id: variable
  parameters:
    value: '[(i * 1e6) + 5.7325e9 for i in channels_5ghz]'
  states: {}
- name: if_gain
  id: variable_qtgui_range
  parameters:
    label: IF Gain
    outputmsgname: value
    rangeType: int
    showports: 'False'
    start: '0'
    step: '8'
    stop: '40'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 15.36e6
  states: {}
- name: zc_seq
  id: variable
  parameters:
    value: dji_droneid.utils.create_zc(fft_size, 4)
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: float
  states: {}
- name: blocks_complex_to_mag_1
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_1
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_divide_xx_0
  id: blocks_divide_xx
  parameters:
    type: complex
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: fft_size
    max_iter: '4000'
    scale: 1 / (fft_size - 1)
    type: float
  states: {}
- name: blocks_multiply_const_xx_0
  id: blocks_multiply_const_xx
  parameters:
    const: 1 / fft_size
    type: complex
  states: {}
- name: blocks_multiply_const_xx_0_0
  id: blocks_multiply_const_xx
  parameters:
    const: dji_droneid.utils.variance_vector(zc_seq)
    type: float
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: fosphor_channel
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {state: disabled}
- name: blocks_transcendental_0
  id: blocks_transcendental
  parameters:
    name: sqrt
    type: float
  states: {}
- name: fft_filter_xxx_0
  id: fft_filter_xxx
  parameters:
    decim: '1'
    taps: dji_droneid.utils.conj_vector(zc_seq)
    type: ccc
  states: {}
- name: filter_fft_low_pass_filter_0
  id: filter_fft_low_pass_filter
  parameters:
    cutoff_freq: 5e6
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: ccc
    width: 100e3
    win: window.WIN_HAMMING
  states: {}
- name: fosphor_glfw_sink_c_0
  id: fosphor_glfw_sink_c
  parameters:
    freq_center: '0'
    freq_span: samp_rate
  states: {state: disabled}
- name: import_0
  id: import
  parameters:
    imports: from gnuradio import dji_droneid
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    bb_gain0: bb_gain
    bw0: 10e6
    freq0: freq
    gain0: '0'
    gain_mode0: 'False'
    if_gain0: if_gain
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    label1: Correlator Output
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_float_to_complex_0, '1']
- [blocks_complex_to_mag_1, '0', qtgui_time_sink_x_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_complex_to_mag_squared_1, '0', blocks_nlog10_ff_0, '0']
- [blocks_divide_xx_0, '0', blocks_complex_to_mag_1, '0']
- [blocks_float_to_complex_0, '0', blocks_divide_xx_0, '1']
- [blocks_moving_average_xx_0, '0', blocks_multiply_const_xx_0_0, '0']
- [blocks_multiply_const_xx_0, '0', blocks_divide_xx_0, '0']
- [blocks_multiply_const_xx_0_0, '0', blocks_transcendental_0, '0']
- [blocks_nlog10_ff_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_selector_0, '0', fosphor_glfw_sink_c_0, '0']
- [blocks_transcendental_0, '0', blocks_float_to_complex_0, '0']
- [fft_filter_xxx_0, '0', blocks_multiply_const_xx_0, '0']
- [filter_fft_low_pass_filter_0, '0', blocks_complex_to_mag_squared_0, '0']
- [filter_fft_low_pass_filter_0, '0', blocks_complex_to_mag_squared_1, '0']
- [filter_fft_low_pass_filter_0, '0', blocks_selector_0, '1']
- [filter_fft_low_pass_filter_0, '0', fft_filter_xxx_0, '0']
- [osmosdr_source_0, '0', blocks_selector_0, '0']
- [osmosdr_source_0, '0', filter_fft_low_pass_filter_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.3.0
