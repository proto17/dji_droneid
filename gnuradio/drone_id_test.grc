options:
  parameters:
    author: David Protzman
    generate_options: qt_gui
    id: drone_id_demod_test
    output_language: python
    title: Testing DroneID Demodulation
  states: {}

blocks:
- name: debug_dir
  id: variable
  parameters:
    value: '"/tmp/droneid_debug"'
  states: {}
- name: decimation
  id: variable
  parameters:
    value: '1'
  states: {}
- name: delay
  id: variable_qtgui_range
  parameters:
    label: Delay
    outputmsgname: value
    rangeType: int
    showports: 'False'
    start: '0'
    step: '1'
    stop: '100000'
    value: int(fft_size * 6) + long_cp_len + (short_cp_len * 3) - 1
  states: {}
- name: fft_size
  id: variable
  parameters:
    value: samp_rate / decimation / 15e3
  states: {}
- name: filter_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: 5e6
    gain: '1.0'
    samp_rate: samp_rate
    width: 750e3
    win: window.WIN_HAMMING
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    label: Freq
    outputmsgname: value
    showports: 'False'
    start: 60e6
    step: .5e6
    stop: 6e9
    value: '2429500000'
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    label: Gain
    outputmsgname: value
    showports: 'False'
    start: '0'
    step: '0.05'
    stop: '1'
    value: '.55'
  states: {}
- name: long_cp_len
  id: variable
  parameters:
    value: round(0.0000052 * samp_rate / decimation)
  states: {}
- name: offset
  id: variable_qtgui_range
  parameters:
    label: Offset
    outputmsgname: value
    showports: 'False'
    start: '-samp_rate/2'
    step: .5e6
    stop: samp_rate/2
    value: 7.5e6
  states: {state: disabled}
- name: samp_rate
  id: variable_qtgui_range
  parameters:
    label: Sample Rate
    outputmsgname: value
    showports: 'False'
    start: 10e6
    step: 1e6
    stop: 56e6
    value: 15.36e6*2
  states: {}
- name: short_cp_len
  id: variable
  parameters:
    value: round(0.00000469 * samp_rate / decimation)
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: offset
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: delay
    type: complex
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /opt/dji/collects/2437MHz_30.72MSPS.fc32
    repeat: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: droneid_demodulation_0
  id: droneid_demodulation
  parameters:
    debug_path: debug_dir
    sample_rate: samp_rate / decimation
  states: {}
- name: droneid_extractor_0
  id: droneid_extractor
  parameters:
    sample_rate: samp_rate / decimation
    threshold: '0.15'
  states: {}
- name: fft_filter_xxx_0
  id: fft_filter_xxx
  parameters:
    decim: decimation
    taps: filter_taps
    type: ccc
  states: {}
- name: fft_filter_xxx_1
  id: fft_filter_xxx
  parameters:
    alias: corr_filt
    decim: '1'
    taps: droneid.misc_utils.conj(droneid.misc_utils.create_zc_sequence(samp_rate/decimation, 600))
    type: ccc
  states: {}
- name: fosphor_glfw_sink_c_0
  id: fosphor_glfw_sink_c
  parameters:
    freq_center: '0'
    freq_span: samp_rate
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from gnuradio import droneid
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    bb_gain0: '20'
    bw0: 10e6
    freq0: freq
    gain0: gain * 30
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    type: msg_complex
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    bw0: 12e6
    center_freq0: uhd.tune_request_t(freq, 6e6)
    dev_args: '""'
    gain0: gain
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [blocks_complex_to_mag_squared_0, '0', droneid_extractor_0, '1']
- [blocks_complex_to_mag_squared_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_delay_0, '0', droneid_extractor_0, '0']
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_multiply_xx_0, '0', fft_filter_xxx_0, '0']
- [blocks_throttle_0, '0', blocks_multiply_xx_0, '0']
- [droneid_demodulation_0, pdus, qtgui_const_sink_x_0, in]
- [droneid_extractor_0, pdus, droneid_demodulation_0, pdus]
- [fft_filter_xxx_0, '0', blocks_delay_0, '0']
- [fft_filter_xxx_0, '0', fft_filter_xxx_1, '0']
- [fft_filter_xxx_0, '0', fosphor_glfw_sink_c_0, '0']
- [fft_filter_xxx_1, '0', blocks_complex_to_mag_squared_0, '0']
- [osmosdr_source_0, '0', fft_filter_xxx_0, '0']
- [uhd_usrp_source_0, '0', fft_filter_xxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.3.0
